# IAR project aws_demos.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F565NE R5F565NE
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x3000
  General.IStackSize: 0x3000
  General.HeapSize: 0x2000
  ICCRX.CCDefines: __BYTE_ORDER__; __ORDER_LITTLE_ENDIAN__
  ICCRX.CCIncludePath2: src\smc_gen\r_bsp_rx65n2mb; src\smc_gen\r_bsp_rx65n2mb\board\rskrx65n_2mb; src\smc_gen\r_bsp_rx65n2mb\mcu\all; src\smc_gen\r_bsp_rx65n2mb\mcu\rx65n; src\smc_gen\r_bsp_rx65n2mb\mcu\rx65n\register_access; src\smc_gen\r_byteq; src\smc_gen\r_byteq\src; src\smc_gen\r_cmt_rx; src\smc_gen\r_config; src\smc_gen\r_ether_rx; src\smc_gen\r_ether_rx\src; src\smc_gen\r_ether_rx\phy; src\smc_gen\r_flash_rx; src\smc_gen\r_flash_rx\src; src\smc_gen\r_flash_rx\src\targets\rx65n; src\smc_gen\r_flash_rx\src\flash_type_1; src\smc_gen\r_flash_rx\src\flash_type_2; src\smc_gen\r_flash_rx\src\flash_type_3; src\smc_gen\r_flash_rx\src\flash_type_4; src\smc_gen\r_pincfg; src\smc_gen\r_sci_rx; src\smc_gen\r_sci_rx\targets\rx65n; src\smc_gen\general; src\compiler_support; ..\common\config_files; ..\common\application_code; ..\..\..\..\lib\include; ..\..\..\..\lib\third_party\mbedtls\include; ..\..\..\..\lib\include\private; ..\..\..\..\lib\FreeRTOS\portable\IAR\RXv2; ..\..\..\common\include; ..\..\..\..\lib\third_party\pkcs11; ..\..\..\..\lib\third_party\jsmn; ..\..\..\..\lib\third_party\tinycbor; ..\..\..\..\lib\third_party\tracealyzer_recorder\Include; ..\..\..\..\lib\ota\portable\renesas\rx65n-envision-kit; ..\..\..\..\lib\FreeRTOS-Plus-TCP\include; ..\..\..\..\lib\FreeRTOS-Plus-TCP\source\portable\Compiler\IAR
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: aws_demos.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  General.OGChipSelectMenu: RX600  Generic RX600
  General.StackSize: 0x800
  General.IStackSize: 0x800
  General.HeapSize: 0x800
  ICCRX.CCDefines: NDEBUG
  group demos/common
    ../../../common/: directories.txt
  group demos/common/demo_runner
    ../../../common/demo_runner/: aws_demo_runner.c
  group demos/common/devmode_key_provisioning
    ../../../common/devmode_key_provisioning/: aws_dev_mode_key_provisioning.c
  group demos/common/devmode_key_provisioning/CertificateConfigurationTool
    ../../../common/devmode_key_provisioning/CertificateConfigurationTool/: CertificateConfigurator.html
  group demos/common/devmode_key_provisioning/CertificateConfigurationTool/js
    ../../../common/devmode_key_provisioning/CertificateConfigurationTool/js/: generator.js
  group demos/common/greengrass_connectivity
    ../../../common/greengrass_connectivity/: aws_greengrass_discovery_demo.c README.md
  group demos/common/include
    ../../../common/include/: aws_application_version.h aws_clientcredential.h aws_clientcredential_keys.h aws_demo.h aws_demo_runner.h aws_dev_mode_key_provisioning.h aws_greengrass_discovery_demo.h aws_hello_world.h aws_logging_task.h aws_ota_update_demo.h aws_shadow_lightbulb_on_off.h aws_simple_tcp_echo_server.h aws_subscribe_publish_loop.h aws_tcp_echo_client_single_tasks.h
  group demos/common/logging
    ../../../common/logging/: aws_logging_task_dynamic_buffers.c
  group demos/common/mqtt
    ../../../common/mqtt/: aws_hello_world.c aws_subscribe_publish_loop.c
  group demos/common/ota
    ../../../common/ota/: aws_ota_update_demo.c
  group demos/common/shadow
    ../../../common/shadow/: aws_shadow_lightbulb_on_off.c
  group demos/common/tcp
    ../../../common/tcp/: aws_simple_tcp_echo_server.c aws_tcp_echo_client_separate_tasks.c aws_tcp_echo_client_single_task.c
  group demos/renesas/rx65n-envision-kit/common/application_code
    ../common/application_code/: entropy_hardware_poll.c freertos_usr_func.c freertos_usr_func.h helper.c main.c rskrx65n_uart.c rskrx65n_uart.h time.h
  group demos/renesas/rx65n-envision-kit/common/config_files
    ../common/config_files/: aws_bufferpool_config.h aws_demo_config.h aws_ggd_config.h aws_mqtt_agent_config.h aws_mqtt_config.h aws_pkcs11_config.h aws_secure_sockets_config.h aws_shadow_config.h aws_wifi_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/compiler_support
    src/compiler_support/: SCFGcompiler.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/general
    src/smc_gen/general/: r_cg_hardware_setup.c r_cg_macrodriver.h r_cg_userdefine.h r_smc_cgc.c r_smc_cgc.h r_smc_cgc_user.c r_smc_entry.h r_smc_interrupt.c r_smc_interrupt.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb
    src/smc_gen/r_bsp_rx65n2mb/: platform.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/board/rskrx65n_2mb
    src/smc_gen/r_bsp_rx65n2mb/board/rskrx65n_2mb/: hwsetup.c hwsetup.h r_bsp.h r_bsp_config_reference.h r_bsp_interrupt_config_reference.h resetprg.c rskrx65n_2mb.h vecttbl.c vecttbl.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/board/user
    src/smc_gen/r_bsp_rx65n2mb/board/user/: r_bsp.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/doc/en
    src/smc_gen/r_bsp_rx65n2mb/doc/en/: r01an3512ej0050-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/doc/ja
    src/smc_gen/r_bsp_rx65n2mb/doc/ja/: r01an3512jj0050-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/mcu/all
    src/smc_gen/r_bsp_rx65n2mb/mcu/all/: r_bsp_common.c r_bsp_common.h r_typedefs.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/mcu/rx65n
    src/smc_gen/r_bsp_rx65n2mb/mcu/rx65n/: cpu.c cpu.h locking.c locking.h mcu_clocks.c mcu_info.h mcu_init.c mcu_init.h mcu_interrupts.c mcu_interrupts.h mcu_locks.c mcu_locks.h mcu_mapped_interrupts.c mcu_mapped_interrupts.h mcu_mapped_interrupts_private.h mcu_startup.c mcu_startup.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_bsp_rx65n2mb/mcu/rx65n/register_access
    src/smc_gen/r_bsp_rx65n2mb/mcu/rx65n/register_access/: iodefine.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_byteq
    src/smc_gen/r_byteq/: r_byteq_if.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_byteq/doc
    src/smc_gen/r_byteq/doc/: r01an1683jj0160_rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_byteq/ref
    src/smc_gen/r_byteq/ref/: r_byteq_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_byteq/src
    src/smc_gen/r_byteq/src/: r_byteq.c r_byteq_private.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_cmt_rx
    src/smc_gen/r_cmt_rx/: r_cmt_rx_if.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_cmt_rx/doc/en
    src/smc_gen/r_cmt_rx/doc/en/: r01an1856ej0320-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_cmt_rx/doc/ja
    src/smc_gen/r_cmt_rx/doc/ja/: r01an1856jj0320-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_cmt_rx/ref
    src/smc_gen/r_cmt_rx/ref/: r_cmt_rx_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_cmt_rx/src
    src/smc_gen/r_cmt_rx/src/: r_cmt_rx.c
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config_readme.txt r_bsp_interrupt_config.h r_byteq_config.h r_cmt_rx_config.h r_ether_rx_config.h r_flash_rx_config.h r_sci_rx_config.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx
    src/smc_gen/r_ether_rx/: r_ether_rx_if.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/doc/en
    src/smc_gen/r_ether_rx/doc/en/: r01an2009ej0113-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/doc/ja
    src/smc_gen/r_ether_rx/doc/ja/: r01an2009jj0113-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/ref
    src/smc_gen/r_ether_rx/ref/: r_ether_rx_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/src
    src/smc_gen/r_ether_rx/src/: r_ether_rx.c r_ether_rx_private.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/src/phy
    src/smc_gen/r_ether_rx/src/phy/: phy.c phy.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_ether_rx/src/targets/rx65n
    src/smc_gen/r_ether_rx/src/targets/rx65n/: r_ether_setting_rx65n.c
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx
    src/smc_gen/r_flash_rx/: r_flash_rx_if.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/doc/en
    src/smc_gen/r_flash_rx/doc/en/: r01an2184eu0320-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/doc/ja
    src/smc_gen/r_flash_rx/doc/ja/: r01an2184ju0320-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/ref
    src/smc_gen/r_flash_rx/ref/: r_flash_rx_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src
    src/smc_gen/r_flash_rx/src/: r_flash_fcu.c r_flash_fcu.h r_flash_group.c r_flash_group.h r_flash_rx.c r_flash_rx.h r_flash_targets.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src/flash_type_1
    src/smc_gen/r_flash_rx/src/flash_type_1/: r_codeflash.c r_codeflash.h r_codeflash_extra.c r_codeflash_extra.h r_dataflash.c r_dataflash.h r_flash_common.h r_flash_type1.c r_flash_type1_if.h r_flash_utils.c
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src/flash_type_2
    src/smc_gen/r_flash_rx/src/flash_type_2/: r_flash_type2.c r_flash_type2_if.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src/flash_type_3
    src/smc_gen/r_flash_rx/src/flash_type_3/: r_flash_type3.c r_flash_type3_if.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src/flash_type_4
    src/smc_gen/r_flash_rx/src/flash_type_4/: r_flash_type4.c r_flash_type4_if.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_flash_rx/src/targets/rx65n
    src/smc_gen/r_flash_rx/src/targets/rx65n/: r_flash_rx65n.h r_mcu_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_ether_rx_pinset.c r_ether_rx_pinset.h r_pinset.h r_sci_rx_pinset.c r_sci_rx_pinset.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx
    src/smc_gen/r_sci_rx/: r_sci_rx_if.h readme.txt
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx/doc/en
    src/smc_gen/r_sci_rx/doc/en/: r01an1815ej0200-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx/doc/ja
    src/smc_gen/r_sci_rx/doc/ja/: r01an1815jj0200-rx.pdf
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx/ref
    src/smc_gen/r_sci_rx/ref/: r_sci_rx_config_reference.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx/src
    src/smc_gen/r_sci_rx/src/: r_sci_rx.c r_sci_rx_platform.h r_sci_rx_private.h
  group demos/renesas/rx65n-envision-kit/iar-ewrx/src/smc_gen/r_sci_rx/src/targets/rx65n
    src/smc_gen/r_sci_rx/src/targets/rx65n/: r_sci_rx65n.c r_sci_rx65n_data.c r_sci_rx65n_private.h
  group lib/bufferpool
    ../../../../lib/bufferpool/: aws_bufferpool_static_thread_safe.c
  group lib/crypto
    ../../../../lib/crypto/: aws_crypto.c
  group lib/FreeRTOS
    ../../../../lib/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group lib/FreeRTOS/portable/IAR/RXv2
    ../../../../lib/FreeRTOS/portable/IAR/RXv2/: port.c port_asm.s portmacro.h
  group lib/FreeRTOS/portable/MemMang
    ../../../../lib/FreeRTOS/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c ReadMe.url
  group lib/FreeRTOS-Plus-TCP/include
    ../../../../lib/FreeRTOS-Plus-TCP/include/: FreeRTOS_ARP.h FreeRTOS_DHCP.h FreeRTOS_DNS.h FreeRTOS_errno_TCP.h FreeRTOS_IP.h FreeRTOS_IP_Private.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
  group lib/FreeRTOS-Plus-TCP/source
    ../../../../lib/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c History.txt readme.txt ReadMe.url
  group lib/FreeRTOS-Plus-TCP/source/portable/BufferManagement
    ../../../../lib/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_1.c BufferAllocation_2.c
  group lib/FreeRTOS-Plus-TCP/source/portable/Compiler/IAR
    ../../../../lib/FreeRTOS-Plus-TCP/source/portable/Compiler/IAR/: pack_struct_end.h pack_struct_start.h
  group lib/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/RX
    ../../../../lib/FreeRTOS-Plus-TCP/source/portable/NetworkInterface/RX/: ether_callback.c NetworkInterface.c
  group lib/greengrass
    ../../../../lib/greengrass/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group lib/include
    ../../../../lib/include/: aws_crypto.h aws_greengrass_discovery.h aws_mqtt_agent.h aws_mqtt_lib.h aws_ota_agent.h aws_pkcs11.h aws_secure_sockets.h aws_shadow.h aws_system_init.h aws_tls.h aws_wifi.h event_groups.h FreeRTOS.h message_buffer.h queue.h semphr.h stream_buffer.h task.h timers.h
  group lib/include/private
    ../../../../lib/include/private/: aws_bufferpool.h aws_default_root_certificates.h aws_doubly_linked_list.h aws_ggd_config_defaults.h aws_helper_secure_connect.h aws_lib_init.h aws_mqtt_agent_config_defaults.h aws_mqtt_buffer.h aws_mqtt_config_defaults.h aws_ota_agent_internal.h aws_ota_cbor.h aws_ota_cbor_internal.h aws_ota_pal.h aws_ota_types.h aws_rsprintf.h aws_secure_sockets_config_defaults.h aws_shadow_config_defaults.h aws_shadow_json.h deprecated_definitions.h list.h mpu_wrappers.h portable.h projdefs.h stack_macros.h
  group lib/mqtt
    ../../../../lib/mqtt/: aws_mqtt_agent.c aws_mqtt_lib.c
  group lib/ota
    ../../../../lib/ota/: aws_ota_agent.c aws_ota_cbor.c aws_rsprintf.c
  group lib/ota/portable/renesas/rx65n-envision-kit
    ../../../../lib/ota/portable/renesas/rx65n-envision-kit/: aws_ota_pal.c
  group lib/pkcs11/mbedtls
    ../../../../lib/pkcs11/mbedtls/: aws_pkcs11_mbedtls.c
  group lib/pkcs11/portable/renesas/rx65n-envision-kit
    ../../../../lib/pkcs11/portable/renesas/rx65n-envision-kit/: aws_pkcs11_pal.c
  group lib/secure_sockets/portable/renesas/rx65n-envision-kit
    ../../../../lib/secure_sockets/portable/renesas/rx65n-envision-kit/: aws_secure_sockets.c
  group lib/shadow
    ../../../../lib/shadow/: aws_shadow.c aws_shadow_json.c
  group lib/third_party
    ../../../../lib/third_party/: directories.txt
  group lib/third_party/jsmn
    ../../../../lib/third_party/jsmn/: jsmn.c jsmn.h
  group lib/third_party/mbedtls
    ../../../../lib/third_party/mbedtls/: LICENSE
  group lib/third_party/mbedtls/include/mbedtls
    ../../../../lib/third_party/mbedtls/include/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h cmac.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h ecp_internal.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h net_sockets.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs12.h pkcs5.h platform.h platform_time.h ripemd160.h rsa.h rsa_internal.h sha1.h sha256.h sha512.h ssl.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h
  group lib/third_party/mbedtls/library
    ../../../../lib/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c Makefile md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group lib/third_party/pkcs11
    ../../../../lib/third_party/pkcs11/: pkcs11.h pkcs11f.h pkcs11t.h
  group lib/third_party/tinycbor
    ../../../../lib/third_party/tinycbor/: assert_p.h cbor.h cborconstants_p.h cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c compilersupport_p.h extract_number_p.h LICENSE math_support_p.h
  group lib/third_party/tracealyzer_recorder
    ../../../../lib/third_party/tracealyzer_recorder/: readme.txt ReadMe.url trcKernelPort.c trcSnapshotRecorder.c trcStreamingRecorder.c
  group lib/third_party/tracealyzer_recorder/config
    ../../../../lib/third_party/tracealyzer_recorder/config/: trcConfig.h trcSnapshotConfig.h trcStreamingConfig.h
  group lib/third_party/tracealyzer_recorder/Include
    ../../../../lib/third_party/tracealyzer_recorder/Include/: trcHardwarePort.h trcKernelPort.h trcPortDefines.h trcRecorder.h
  group lib/third_party/tracealyzer_recorder/streamports/Jlink_RTT
    ../../../../lib/third_party/tracealyzer_recorder/streamports/Jlink_RTT/: Readme-Streamport.txt SEGGER_RTT.c SEGGER_RTT_Printf.c
  group lib/third_party/tracealyzer_recorder/streamports/Jlink_RTT/include
    ../../../../lib/third_party/tracealyzer_recorder/streamports/Jlink_RTT/include/: SEGGER_RTT.h SEGGER_RTT_Conf.h trcStreamingPort.h
  group lib/third_party/tracealyzer_recorder/streamports/TCPIP
    ../../../../lib/third_party/tracealyzer_recorder/streamports/TCPIP/: Readme-Streamport.txt trcStreamingPort.c
  group lib/third_party/tracealyzer_recorder/streamports/TCPIP/include
    ../../../../lib/third_party/tracealyzer_recorder/streamports/TCPIP/include/: trcStreamingPort.h
  group lib/third_party/tracealyzer_recorder/streamports/USB_CDC
    ../../../../lib/third_party/tracealyzer_recorder/streamports/USB_CDC/: Readme-Streamport.txt trcStreamingPort.c
  group lib/third_party/tracealyzer_recorder/streamports/USB_CDC/include
    ../../../../lib/third_party/tracealyzer_recorder/streamports/USB_CDC/include/: trcStreamingPort.h
  group lib/tls
    ../../../../lib/tls/: aws_tls.c
  group lib/utils
    ../../../../lib/utils/: aws_system_init.c
  group lib/wifi/portable/renesas/x65n-envision-kit
    ../../../../lib/wifi/portable/renesas/rx65n-envision-kit/: aws_wifi.c
